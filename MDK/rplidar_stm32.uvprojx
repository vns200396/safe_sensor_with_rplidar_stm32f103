# Keil uVision project rplidar_stm32.uvprojx, settings and files
target base_stm32f103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rplidar_stm32
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\Main;..\Source\RPLidar_Driver;..\Source\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ../Source/System/: system.c SysTick.c
  group RPLidar_Driver
    ../Source/RPLidar_Driver/: lidar_hardware_serial.h rplidar_cmd.h rplidar_protocol.h rptypes.h RPLidar.h scan_space.h lidar_hardware_serial.c RPLidar.c scan_space.c
  group Main
    ../Source/Main/: main.c stm32f10x_it.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
